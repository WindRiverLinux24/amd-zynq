require linux-yocto-xilinx-zynq.inc

KBRANCH:xilinx-zynq  = "v5.10/standard/sdkv5.10/xlnx-soc"

LINUX_VERSION:xilinx-zynq ?= "5.10.x"
