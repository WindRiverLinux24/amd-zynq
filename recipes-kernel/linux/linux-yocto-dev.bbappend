require linux-yocto-xilinx-zynq.inc 

KBRANCH:xilinx-zynq  = "standard/xlnx-soc"

LINUX_VERSION:xilinx-zynq ?= "5.13.x"
