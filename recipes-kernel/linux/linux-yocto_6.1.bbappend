require linux-yocto-xilinx-zynq.inc

KBRANCH:xilinx-zynq  = "v6.1/standard/sdkv6.1/xlnx-soc"
