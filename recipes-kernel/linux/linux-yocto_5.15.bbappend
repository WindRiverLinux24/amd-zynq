require linux-yocto-xilinx-zynq.inc

KBRANCH:xilinx-zynq  = "v5.15/standard/sdkv5.15/xlnx-soc"

LINUX_VERSION:xilinx-zynq ?= "5.15.x"
