require linux-yocto-xilinx-zynq.inc

KBRANCH_xilinx-zynq  = "v5.4/standard/xlnx-soc"

LINUX_VERSION_xilinx-zynq ?= "5.4.x"
