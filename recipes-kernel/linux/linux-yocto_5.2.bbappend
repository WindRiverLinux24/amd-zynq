require linux-yocto-xilinx-zynq.inc

KBRANCH_xilinx-zynq  = "v5.2/standard/xlnx-soc"

LINUX_VERSION_xilinx-zynq ?= "5.2.x"
