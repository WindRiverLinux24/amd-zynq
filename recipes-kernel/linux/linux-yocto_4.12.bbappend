include linux-windriver-xilinx-zynq.inc

KBRANCH_xilinx-zynq = "standard/xilinx/sdk2017-04/xilinx-zynq"
