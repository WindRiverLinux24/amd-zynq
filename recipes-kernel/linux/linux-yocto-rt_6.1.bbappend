require linux-yocto-xilinx-zynq.inc

KBRANCH:xilinx-zynq  = "v6.1/standard/preempt-rt/sdkv6.1/xlnx-soc"
