require linux-yocto-xilinx-zynq.inc

KBRANCH_xilinx-zynq  = "v4.18/standard/xilinx/sdk2018-03/xilinx-zynq"
