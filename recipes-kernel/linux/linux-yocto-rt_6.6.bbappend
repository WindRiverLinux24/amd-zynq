require linux-yocto-amd-zynq.inc

KBRANCH:amd-zynq  = "v6.6/standard/preempt-rt/sdkv6.6/xlnx-soc"
